# Keil uVision project four_axis.uvprojx, settings and files
target four_axis (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: four_axis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\CORE;..\SYSTEM;..\STM32F10x_FWLib\inc;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HAREWARE
    ../HARDWARE/: iic_eeprom.c led.c mpu6050.c mpuiic.c NRF24L01.c spi.c time.c uart2.c adc.c NRFCommunication.c my_math.c controller.c Interrupt.c imu.c sins.c nav.c pid_controller.c pid.c APP.C query_tast.c calm_acc.c calm_gyro.c calm_mpu.c bmp280.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
